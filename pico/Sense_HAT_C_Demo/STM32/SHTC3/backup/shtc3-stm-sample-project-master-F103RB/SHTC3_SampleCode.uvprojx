# Keil uVision project SHTC3_SampleCode.uvprojx, settings and files
target STM32-Discovery (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SHTC3_SampleCode +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Source;.\STM32F10x_FWLib\inc;.\STM32F10x_FWLib\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./Source/: startup_stm32f10x_md.s
  group Source Files
    ./Source/: main.c shtc3.c i2c_hal.c system.c
software components: CMSIS:CORE 5.1.1
