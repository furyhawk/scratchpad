# Keil uVision project OLED.uvprojx, settings and files
target OLED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\SRC\Hardware\SPI;..\SRC\Hardware\IIC;..\SRC\STM32F10x_LIB\CMSIS;..\SRC\STM32F10x_LIB\inc;..\SRC\USER;..\SRC\Hardware\delay;..\SRC\Hardware\SSD1305
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Hardware
    ../SRC/Hardware/SPI/: SPI.c
    ../SRC/Hardware/delay/: delay.c
    ../SRC/Hardware/IIC/: IIC.c
    ../SRC/Hardware/SSD1305/: SSD1305.c Fonts.c
  group STM32F10x_LIB
    ../SRC/STM32F10x_LIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../SRC/STM32F10x_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group USER
    ../SRC/USER/: Config.c main.c
software components: CMSIS:CORE 5.1.1
