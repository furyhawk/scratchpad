## esp32/ESP32-S3-Touch-AMOLED-2.06-Demos/01_AXP2101/sdkconfig.defaults
```kconfig
CONFIG_PMU_I2C_SCL=21
CONFIG_PMU_I2C_SDA=22
CONFIG_PMU_INTERRUPT_PIN=-1
CONFIG_I2C_MASTER_FREQUENCY=50000
```
